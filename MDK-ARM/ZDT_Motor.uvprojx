# Keil uVision project ZDT_Motor.uvprojx, settings and files
target ZDT_Motor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: ZDT_Motor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../01_App;../02_Service;../03_Middleware;../03_Middleware/chassis;../03_Middleware/map;../03_Middleware/pid;../04_Bsp;../04_Bsp/zdt_motor;../04_Bsp/hwt101;../04_Bsp/ble;../99_Utils;../99_Utils/rtt
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group 01_App
    ../01_App/: app_main.c
  group 02_Service
    ../02_Service/: system_assembly.c it_dispatch.c chassis_service.c
  group 03_Middleware/chassis
    ../03_Middleware/chassis/: mecanum_chassis.c chassis_adaption.c
  group 03_Middleware/map
    ../03_Middleware/map/: map.c map_adaption.c
  group 03_Middleware/pid
    ../03_Middleware/pid/: pid.c pid_adaption.c
  group 04_Bsp/zdt_motor
    ../04_Bsp/zdt_motor/: zdt_motor.c zdt_motor_handler.c zdt_cmd.c zdt_motor_adaption.c
  group 04_Bsp/hwt101
    ../04_Bsp/hwt101/: hwt101.c hwt101_adaption.c
  group 04_Bsp/ble
    ../04_Bsp/ble/: ble.c ble_adaption.c
  group 99_Utils/rtt
    ../99_Utils/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
